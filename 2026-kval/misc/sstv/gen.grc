options:
  parameters:
    author: mati
    generate_options: qt_gui
    id: gen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: audio_rate*2
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: rf_rate
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ssmtv.cf32
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_rate
    type: float
  states: {state: bypassed}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.9'
    samp_rate: rf_rate
    sensitivity: 5e3
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: sstv.wav
    repeat: 'False'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: audio_rate/rf_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', blocks_file_sink_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', analog_nbfm_tx_0, '0']
- [blocks_throttle2_0, '0', mmse_resampler_xx_0, '0']
- [blocks_vco_c_0, '0', blocks_file_sink_0, '0']
- [blocks_vco_c_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [mmse_resampler_xx_0, '0', blocks_vco_c_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
